# Keil uVision project term_project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: term_project
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: term_project.c
    C:/Keil_v5/ARM/Pack/ARM/CMSIS/lpc175x_6x_cmsis_driver_library/Drivers/source/: debug_frmwrk.c lpc17xx_clkpwr.c lpc17xx_pinsel.c lpc17xx_uart.c lpc17xx_timer.c
software components: CMSIS:CORE 3.40.0, Board Support:LED 1.0.0, Device:GPIO 1.00, Device:PIN 1.00, Device:Startup 1.0.0
